Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-10-21T15:45:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 21 15:45:07 2022 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{D583A886-4BD4-4327-B784-9A6A826D872C}\ifc * Database version: 5507 * Database creation date: Fri Oct 21 15:45:06 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 21 15:45:06 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 21 15:45:06 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Drop Box Brick RE, Vitra-Home_Office-Drop_Box:Drop Box Brick RE:346673
In: Level 1
Type - ElementType: Drop Box Brick RE; Material: Brick RE, Aluminium, Brick
Type - General - Author: BIMStone; BIMObjectName: Vitra-Home_Office-Drop_Box; ManufacterURL: https://www.vitra.com/; ManufacturerName: Vitra; NBSDescription: Office storage; NBSReference: 45-35-80/360; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_78_90; Uniclass2015Description: Tool chests; Uniclass2015Reference: Pr_40_30_87_90; Version: 1; VersionDate: 28/09/2022
Type - Identity Data - Cost: 0; Description: Drop Box by Konstantin Grcic keeps work utensils near at hand, but is also useful in children's rooms, kitchens, living rooms, hallways or waiting rooms.; Designer: Konstantin Grcic; Manufacturer: Vitra; Model: Drop Box Brick RE; OmniClass Number: 23.40.20.31; OmniClass Title: Refuse Disposal Furniture; Type Name: Drop Box Brick RE; URL: https://www.vitra.com/living/product/details/drop-box
Type - Materials and Finishes - ColorMaterial: Brick; SidePanelsMaterial: Brick RE; TubesMaterial: Aluminium
Type - Other - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Tool dispensers; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Home_Office-Drop_Box; Features: Drop Box is light and easy to handle. It comes in a choice of colours and can be quickly dismantled if required. Name tags for personalisation are off ered in various hues. The Drop Box Tray Set can be ordered separately and simply ‚clicked‘ into place on two diff erent levels.; Finish: Side panels: recycled polypropylene, 100% recyclable. Tubes: aluminium. Fabric: 100% polyester.; Grade: n/a; Material: Polypropylene,fabric and polyester; ModelNumber: n/a; ModelReference: n/a; Name: Drop_Box; ReplacementCost: n/a; Shape: Sculptured; Size: 400x550x270 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; Tray: yes
Construction - MetaProperties_Tray: Drop Box Tray Set
Dimensions - Area: 0.47486 m2; Volume: 0.059103 m3
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Vitra-Home_Office-Drop_Box: Drop Box Brick RE; Family and Type: Vitra-Home_Office-Drop_Box: Drop Box Brick RE; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Home_Office-Drop_Box: Drop Box Brick RE; Type Id: Vitra-Home_Office-Drop_Box: Drop Box Brick RE; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
